# Keil uVision project STM32F407VET6_FLY_BUTTON.uvprojx, settings and files
target STM32F407VET6_FLY_BUTTON (6180000::V6.18::ARMCLANG)
  device: STM32F407VETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.16.0
  cpu: IRAM(0x20000000-0x2001BFFF) IRAM2(0x2001C000-0x2001FFFF) IROM(0x8000000-0x807FFFF) CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: STM32F407VET6_FLY_BUTTON +hex
  c flags: Optim=7 OneElfS=1 uC99=1 v6Lang=4 v6LangP=4 wLevel=3
  c define: USE_HAL_DRIVER,STM32F407xx,TFT18
  c include: ../Core/Inc;../RT-Thread;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/CMSIS/Include;../Middlewares/Third_Party/RealThread_RTOS/include/;../Middlewares/Third_Party/RealThread_RTOS/bsp/_template/cubemx_config;../Middlewares/Third_Party/RealThread_RTOS/finsh/;../Middlewares/Third_Party/RealThread_RTOS/components/finsh;../HARDWARE;../HARDWARE/ST7735;../SOFTWARE;../SOFTWARE/MultiButton;../SOFTWARE/my_cmd;../SOFTWARE/rtt_ringbuffer;../SOFTWARE/usart_tras;../TASK;../TASK/USART1_TASK;../TASK/USART3_TASK;../TASK/UART4_TASK;../TASK/UART5_TASK;..\TASK\LVGL_TASK
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x1c000
  memory RVCT10: RAM 0x2001c000 size 0x4000
  group Application/MDK-ARM
    ./: startup_stm32f407xx.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c adc.c dma.c spi.c usart.c stm32f4xx_it.c stm32f4xx_hal_msp.c stm32f4xx_hal_timebase_tim.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_adc.c stm32f4xx_hal_adc_ex.c stm32f4xx_ll_adc.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_hal_spi.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f4xx.c
  group SOFTWARE
    ../SOFTWARE/my_cmd/: my_cmd.c my_cmd.h
    ../SOFTWARE/rtt_ringbuffer/: ringbuffer.c ringbuffer.h
    ../SOFTWARE/MultiButton/: multi_button.c multi_button.h
    ../SOFTWARE/usart_tras/: my_usart.c my_usart.h
    ../TASK/LVGL_TASK/: lvgl_pic_sample.h
  group TASK
    ../TASK/USART1_TASK/: usart1_task.c usart1_task.h
    ../TASK/USART3_TASK/: usart3_task.c usart3_task.h
    ../TASK/UART4_TASK/: uart4_task.c uart4_task.h
    ../TASK/UART5_TASK/: uart5_task.c uart5_task.h
    ../TASK/LVGL_TASK/: lvgl_task.c lvgl_task.h
  group ST7735
    ../HARDWARE/ST7735/: SEEKFREE_18TFT.c SEEKFREE_18TFT.h SEEKFREE_FONT.c SEEKFREE_FONT.h
  group Middlewares/RT-Thread/RTOS/kernel
    ../Middlewares/Third_Party/RealThread_RTOS/libcpu/arm/cortex-m4/: context_rvds.S cpuport.c
    ../Middlewares/Third_Party/RealThread_RTOS/src/: clock.c components.c cpu.c idle.c ipc.c irq.c kservice.c mem.c memheap.c mempool.c object.c scheduler.c slab.c thread.c timer.c
    ../Middlewares/Third_Party/RealThread_RTOS/bsp/_template/cubemx_config/: board.c
  group Middlewares/RT-Thread/RTOS/shell
    ../Middlewares/Third_Party/RealThread_RTOS/components/finsh/: cmd.c finsh_port.c msh.c shell.c
  group Middlewares/RT-Thread/RTOS/device
    ../Middlewares/Third_Party/RealThread_RTOS/components/device/: device.c
software components: CMSIS:CORE 5.6.0, LVGL:lvgl:Essential 8.3.0, LVGL:lvgl:Extra Themes 8.3.0, LVGL:lvgl:Porting 8.3.0
